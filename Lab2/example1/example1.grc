<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Sampling_example</value></param>
<param><key>author</key><value>Alexandros-Apostolos A. Boulogeorgos</value></param>
<param><key>description</key><value>Change the sample rate (sr) of the audio file and listen what happens. </value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Sampling example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sr</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>sr</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sr</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/Users/ampoulog/Documents/gnuradio/Wireless-communication-systems-Lab/Lab2/example1/Yamaha-V50-Rock-Beat-120bpm.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>sr</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
